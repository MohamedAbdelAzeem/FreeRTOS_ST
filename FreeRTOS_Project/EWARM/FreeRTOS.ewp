# IAR project FreeRTOS.ewp, settings and files
configuration FreeRTOS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA55CG ST STM32WBA55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WBA55xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32WBAxx_HAL_Driver/Inc; ../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/STM32WBAxx_Nucleo; ../freertos/include; C:\mySpace\FreeRTOS\Training\Project\FreeRTOS_Project\freertos\portable\IAR\ARM_CM33_NTZ\non_secure
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:\mySpace\FreeRTOS\Training\Project\FreeRTOS_Project\freertos\portable\IAR\ARM_CM33_NTZ\non_secure; C:\mySpace\FreeRTOS\Training\Project\FreeRTOS_Project\freertos\include; C:\mySpace\FreeRTOS\Training\Project\FreeRTOS_Project\Inc
  OBJCOPY.OOCOutputFile: FreeRTOS.hex
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkIcfFile: stm32wba55xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba55xx.s
  group Application/User
    ../Src/: main.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_irda.c stm32wbaxx_hal_iwdg.c stm32wbaxx_hal_lptim.c stm32wbaxx_hal_pcd.c stm32wbaxx_hal_pcd_ex.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_usart.c stm32wbaxx_hal_usart_ex.c stm32wbaxx_hal_wwdg.c
  group freertos
    ../freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
